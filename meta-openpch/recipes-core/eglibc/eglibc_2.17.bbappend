# To allow to compile eglibc with /usr/local as prefix
EXTRA_OECONF += "--disable-sanity-checks"
