# Compile patch statically
EXTRA_OECONF += "LDFLAGS='-static'"
