# Add this dir to override some patches
FILESEXTRAPATHS_prepend := "${THISDIR}:"
