# Add missing do_deploy function
do_deploy() {
	:
}

addtask deploy after do_install
