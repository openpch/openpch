IMAGE_PKGTYPE = "deb"

require openpch-image.inc
