IMAGE_PKGTYPE = "ipk"

require openpch-image.inc
